# Keil uVision project FreeRTOS_VK01.uvprojx, settings and files
target FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VK01 Milandr
  pack: Keil.MDR1986VK01.1.3
  cpu: IRAM(0x02000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x01000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pwm_rgb
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT
  c include: .\include
  memory RVCT4: ROM 0x1000000 size 0x100000
  memory RVCT9: RAM 0x2000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group usr
    ./: main.c croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c port.c heap_1.c
target RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986VK01 Milandr
  pack: Keil.MDR1986VK01.1.3
  cpu: as above
  output: pwm_rgb
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT
  c include: .\include
  memory RVCT4: ROM 0x2000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, Board Support:DEMOBOARD 1.3, Board Support:Leds 1.3, Device:Startup 1.3, Drivers:CLK 1.3, Drivers:PORT 1.3, Drivers:TIMER 1.3
