# Keil uVision project HelloWorld.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F1QI Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: HelloWorld +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.cmsis-5.4.0CMSISInclude;.cmsis-5.4.0CMSISRTOS2RTXInclude;.cmsis-5.4.0CMSISRTOS2Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c RTX_CM0.lib RTX_Config.c RTX_Config.h rtx_lib.c api_os_tick.c
software components: Device:Startup 2.0.2i, Drivers:PORT 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:TIMER 2.0.2i
